FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0012-linux-user-Do-not-define-struct-sched_attr-if-libc-h.patch"

