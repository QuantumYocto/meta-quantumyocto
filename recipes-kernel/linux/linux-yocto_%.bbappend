FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
PR = "r1"

SRC_URI += "file://kexec.cfg"
